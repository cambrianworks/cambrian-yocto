PACKAGECONFIG:remove = " networkd"
