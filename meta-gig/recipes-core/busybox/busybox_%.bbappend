FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://devmem.cfg \
    file://disable-ip.cfg \
"
