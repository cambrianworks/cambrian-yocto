# Currently, we don't have a use-case for OPTEE so
# this service will always fail. Disable it until
# it's needed.
SYSTEMD_AUTO_ENABLE = "disable"
