PACKAGECONFIG:append:pn-gptfdisk = " ncurses popt"
